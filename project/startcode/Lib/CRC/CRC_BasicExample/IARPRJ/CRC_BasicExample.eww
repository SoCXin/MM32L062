<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\CRC_BasicExample.ewp</path>
	</project>
	<batchBuild />
</workspace>
