<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\I2C_EEPROM_Polling.ewp</path>
	</project>
	<batchBuild />
</workspace>
