<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\USB_HID_Suspend.ewp</path>
	</project>
	<batchBuild />
</workspace>
