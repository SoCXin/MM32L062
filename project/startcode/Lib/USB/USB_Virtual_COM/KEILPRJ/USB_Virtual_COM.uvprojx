# Keil uVision project USB_Virtual_COM.uvprojx, settings and files
target MM32Series (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L062NT MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32L06xx_s\Include;..\..\..\..\..\Device\MM32L06xx_s\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\USB_User\inc;..\USB_lib\inc;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\UART_NVIC;..\HARDWARE\LED;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../Device/MM32L06xx_s/Source/: system_mm32l06xx_s.c
    ../../../../../Device/MM32L06xx_s/Source/KEIL_StartAsm/: startup_mm32l06xx_s_keil.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART_NVIC/: uart_nvic.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USB_lib
    ../USB_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_User
    ../USB_User/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USER
    ../USER/: main.c mm32l0xx_it.c
  group HAL_Lib
    ../../../../../Device/MM32L06xx_s/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
