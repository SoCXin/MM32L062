# IAR project USB_Virtual_COM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32L062NT MindMotion MM32L062NT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: MM32L062NT; USE_IAR; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\MM32L06xx_s\HAL_Lib\Inc; ..\..\..\..\..\Device\MM32L06xx_s\Include; ..\HARDWARE\LED; ..\HARDWARE\UART_NVIC; ..\SYSTEM\DELAY; ..\SYSTEM\SYS; ..\SYSTEM\UART; ..\USB_lib\inc; ..\USB_User\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ADC_Awdg.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HALlib
    ../../../../../Device/MM32L06xx_s/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART_NVIC/: uart_nvic.c
  group STARTUP
    ../../../../../Device/MM32L06xx_s/Source/IAR_StartAsm/: startup_mm32l06xx_s_iar.s
    ../../../../../Device/MM32L06xx_s/Source/: system_mm32l06xx_s.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USB_lib
    ../USB_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_User
    ../USB_User/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USER
    ../USER/: main.c mm32l0xx_it.c
