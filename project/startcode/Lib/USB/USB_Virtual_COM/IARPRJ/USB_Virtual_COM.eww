<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\USB_Virtual_COM.ewp</path>
	</project>
	<batchBuild />
</workspace>
