<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\RCC_CSR_Reset.ewp</path>
	</project>
	<batchBuild />
</workspace>
