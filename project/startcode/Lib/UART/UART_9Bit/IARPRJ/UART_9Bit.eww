<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\UART_9Bit.ewp</path>
	</project>
	<batchBuild />
</workspace>
