<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\TIM1_Monopulse.ewp</path>
	</project>
	<batchBuild />
</workspace>
