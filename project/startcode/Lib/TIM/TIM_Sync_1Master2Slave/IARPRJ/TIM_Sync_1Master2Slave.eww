<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\TIM_Sync_1Master2Slave.ewp</path>
	</project>
	<batchBuild />
</workspace>
