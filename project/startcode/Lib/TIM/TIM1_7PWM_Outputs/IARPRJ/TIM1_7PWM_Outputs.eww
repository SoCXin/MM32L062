<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\TIM1_7PWM_Outputs.ewp</path>
	</project>
	<batchBuild />
</workspace>
