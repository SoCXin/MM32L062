<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\TIM3_PWM_Output.ewp</path>
	</project>
	<batchBuild />
</workspace>
