<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\PWR_Stop_EXTI_GPIO_Wakeup.ewp</path>
	</project>
	<batchBuild />
</workspace>
