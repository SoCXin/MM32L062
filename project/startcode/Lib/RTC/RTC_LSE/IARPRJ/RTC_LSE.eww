<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\RTC_LSE.ewp</path>
	</project>
	<batchBuild />
</workspace>
