<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\SPI_Slave_DMA_Polling.ewp</path>
	</project>
	<batchBuild />
</workspace>
