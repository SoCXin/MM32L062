<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\SPI_GPIO_SIM_EEPROM.ewp</path>
	</project>
	<batchBuild />
</workspace>
