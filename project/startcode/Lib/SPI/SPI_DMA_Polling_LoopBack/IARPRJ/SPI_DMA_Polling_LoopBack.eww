<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\SPI_DMA_Polling_LoopBack.ewp</path>
	</project>
	<batchBuild />
</workspace>
