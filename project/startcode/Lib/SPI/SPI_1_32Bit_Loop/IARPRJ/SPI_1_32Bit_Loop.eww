<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\SPI_1_32Bit_Loop.ewp</path>
	</project>
	<batchBuild />
</workspace>
