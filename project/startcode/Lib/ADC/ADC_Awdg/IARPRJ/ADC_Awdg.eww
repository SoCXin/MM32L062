<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\ADC_Awdg.ewp</path>
	</project>
	<batchBuild />
</workspace>
