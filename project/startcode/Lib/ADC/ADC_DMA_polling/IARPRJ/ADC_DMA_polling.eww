<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\ADC_DMA_polling.ewp</path>
	</project>
	<batchBuild />
</workspace>
