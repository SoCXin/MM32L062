<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\CAN_Filter_20Groups.ewp</path>
	</project>
	<batchBuild />
</workspace>
