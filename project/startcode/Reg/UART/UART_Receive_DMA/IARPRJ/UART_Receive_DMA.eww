<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\UART_Receive_DMA.ewp</path>
	</project>
	<batchBuild />
</workspace>
