<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\SYSTICK_System1msDelay.ewp</path>
	</project>
	<batchBuild />
</workspace>
