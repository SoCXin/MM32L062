<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\TIM1_BasicExample.ewp</path>
	</project>
	<batchBuild />
</workspace>
