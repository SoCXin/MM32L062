<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\WFE_Sleep.ewp</path>
	</project>
	<batchBuild />
</workspace>
