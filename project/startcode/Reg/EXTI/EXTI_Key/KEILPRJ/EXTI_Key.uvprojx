# Keil uVision project EXTI_Key.uvprojx, settings and files
target MM32Series (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L062NT MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32L06xx_s\Include;..\..\..\..\..\Device\MM32L06xx_s\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../Device/MM32L06xx_s/Source/: system_mm32l06xx_s.c
    ../../../../../Device/MM32L06xx_s/Source/KEIL_StartAsm/: startup_mm32l06xx_s_keil.s
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
