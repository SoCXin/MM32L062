# IAR project EXTI_Key.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32L062NT MindMotion MM32L062NT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: MM32L062NT; USE_IAR; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pe1105
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\CMSIS\IAR_Core; ..\..\..\..\..\Device\MM32L06xx_s\HAL_Lib\Inc; ..\..\..\..\..\Device\MM32L06xx_s\Include; ..\HARDWARE\EXTI; ..\HARDWARE\KEY; ..\HARDWARE\LED; ..\SYSTEM\DELAY; ..\SYSTEM\SYS; ..\SYSTEM\UART
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ADC_Awdg.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group STARTUP
    ../../../../../Device/MM32L06xx_s/Source/IAR_StartAsm/: startup_mm32l06xx_s_iar.s
    ../../../../../Device/MM32L06xx_s/Source/: system_mm32l06xx_s.c
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
